## drivers/media/rc/keymaps/Kconfig
```kconfig
config VFD_KEYMAPS
	tristate "vfd keymaps"
	depends on ARM
	default y if ARM
	help
	  vfd Keymaps
```
